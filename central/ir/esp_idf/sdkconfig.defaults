## central/ir/esp_idf/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_UNICORE=n
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
CONFIG_ESP_CONSOLE_UART_BAUDRATE=115200
```
